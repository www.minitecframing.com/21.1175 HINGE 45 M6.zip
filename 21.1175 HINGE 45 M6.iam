# Autodesk Inventor assembly: 21.1175 HINGE 45 M6
## iProperties
Created: 2007-01
Part Number: 21.1175 HINGE 45 M6
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
